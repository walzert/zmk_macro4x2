## boards/shields/macro4x2/Kconfig.defconfig
```kconfig
if SHIELD_MACRO4X2

config ZMK_KEYBOARD_NAME
    default "macro4x2"

config ZMK_USB
	default y

endif
```
